TYPE ST_Test :
STRUCT
	sTestNum : STRING(7);
	nTypeNum : DINT;
	sTimestamp : STRING;
	sTester : STRING;
	sResult : STRING; 
END_STRUCT
END_TYPE
