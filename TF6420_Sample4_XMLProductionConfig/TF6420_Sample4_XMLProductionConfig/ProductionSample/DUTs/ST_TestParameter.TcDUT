TYPE ST_TestParameter :
STRUCT
	rMaxTemp : REAL;
	rMinTemp : REAL;
	nMaxPSI : DINT;
END_STRUCT
END_TYPE
