TYPE ST_Config :
STRUCT
	rLength    : REAL;
	rWidth     : REAL;
	rHeight    : REAL;
	iQuantity  : INT;
	iCounter   : INT;   
END_STRUCT
END_TYPE
